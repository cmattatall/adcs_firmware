<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
<project>
    <path>$WS_DIR$\aes_ex2_encryptDecryptWithFirstRoundKey.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\aes_ex1_encryptDecrypt.ewp</path>
  </project>
  
  <batchBuild/>
</workspace>


