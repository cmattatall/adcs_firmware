<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
<project>
    <path>$WS_DIR$\rtc_a_ex1_calendermode.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\rtc_a_ex2_countermode.ewp</path>
  </project>
  
  <batchBuild/>
</workspace>


