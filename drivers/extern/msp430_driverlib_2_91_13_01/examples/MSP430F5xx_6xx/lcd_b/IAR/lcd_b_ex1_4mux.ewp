# IAR project lcd_b_ex1_4mux.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xsfn.h
  General.OGChipSelectMenu: MSP430FG6626 MSP430FG6626
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: ../../../../driverlib/MSP430F5xx_6xx; ../..
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430FR5969.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  ICC430.CCDefines: DEPRECATED
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  group (top)
    ../: lcd_b_ex1_4mux.c
  group driverlib/MSP430F5xx_6xx
    ../../../../driverlib/MSP430F5xx_6xx/: eusci_b_i2c.h tec.c ctsd16.h sysctl.c eusci_a_spi.c lcd_c.c battbak.h dac12_a.c gpio.c pmm.c timer_b.h usci_b_i2c.c timer_d.h timer_d.c eusci_a_spi.h sd24_b.c eusci_a_uart.h eusci_b_spi.c usci_a_uart.c ucs.c comp_b.h tlv.h dac12_a.h timer_a.h usci_a_uart.h pmm.h ldopwr.c eusci_b_i2c.c sysctl.h adc12_a.c adc10_a.h mpy32.c tlv.c rtc_a.c sfr.h comp_b.c usci_b_spi.c oa.c timer_b.c mpy32.h wdt_a.h flashctl.c rtc_b.c crc.c ucs.h ctsd16.c pmap.c dma.c pmap.h rtc_a.h eusci_a_uart.c usci_b_i2c.h lcd_b.c aes.c usci_b_spi.h ldopwr.h battbak.c lcd_c.h tec.h ref.c rtc_c.h gpio.h adc12_a.h aes.h oa.h rtc_b.h adc10_a.c sd24_b.h ram.h usci_a_spi.c ram.c dma.h driverlib.h ref.h eusci_b_spi.h usci_a_spi.h sfr.c lcd_b.h flashctl.h crc.h timer_a.c rtc_c.c wdt_a.c
  group driverlib/MSP430F5xx_6xx/inc
    ../../../../driverlib/MSP430F5xx_6xx/inc/: hw_memmap.h version.h
