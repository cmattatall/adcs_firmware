<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
<project>
    <path>$WS_DIR$\pmap_ex1_singleRuntimeConfig.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\pmap_ex3_singleFunctionToMultiplePins.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\pmap_ex2_outputTimerBSignal.ewp</path>
  </project>
  
  <batchBuild/>
</workspace>


