<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
<project>
    <path>$WS_DIR$\pmm_ex1_vcore3.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\pmm_ex2_fastWakeUp.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\pmm_ex3_lowCurrentConsumption.ewp</path>
  </project>
  
  <batchBuild/>
</workspace>


