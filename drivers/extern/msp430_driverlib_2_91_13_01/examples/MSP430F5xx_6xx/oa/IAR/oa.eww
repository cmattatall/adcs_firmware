<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
<project>
    <path>$WS_DIR$\oa_ex3_unityGainBuffer.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\oa_ex2_generalPurpose.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\oa_ex1_generalPurpose.ewp</path>
  </project>
  
  <batchBuild/>
</workspace>


