<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
<project>
    <path>$WS_DIR$\tec_ex2_extClearInput.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\tec_ex1_syncTimers.ewp</path>
  </project>
  
  <batchBuild/>
</workspace>


