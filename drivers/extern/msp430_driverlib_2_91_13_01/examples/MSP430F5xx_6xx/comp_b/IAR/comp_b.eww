<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
<project>
    <path>$WS_DIR$\comp_b_ex5_TAx.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\comp_b_ex2_1V5RefInt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\comp_b_ex1_2VRef.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\comp_b_ex3_avccRefULPM.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\comp_b_ex6_extRef.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\comp_b_ex4_hysteresis.ewp</path>
  </project>
  
  <batchBuild/>
</workspace>


