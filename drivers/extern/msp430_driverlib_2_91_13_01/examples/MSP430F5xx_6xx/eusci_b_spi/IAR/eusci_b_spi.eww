<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
<project>
    <path>$WS_DIR$\eusci_b_spi_ex1_master.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\eusci_b_spi_ex1_slave.ewp</path>
  </project>
  
  <batchBuild/>
</workspace>


