<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
<project>
    <path>$WS_DIR$\adc10_b_ex1_avccRef.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\adc10_b_ex2_intRef.ewp</path>
  </project>
  
  <batchBuild/>
</workspace>


