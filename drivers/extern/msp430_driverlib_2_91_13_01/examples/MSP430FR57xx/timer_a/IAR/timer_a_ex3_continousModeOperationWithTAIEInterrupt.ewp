# IAR project timer_a_ex3_continousModeOperationWithTAIEInterrupt.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xsfn.h
  General.OGChipSelectMenu: MSP430FR5739 MSP430FR5739
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: DEPRECATED
  ICC430.newCCIncludePaths: ../../../../driverlib/MSP430FR57xx; ../..
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: lnk0t.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  group (top)
    ../: timer_a_ex3_continousModeOperationWithTAIEInterrupt.c
  group driverlib/MSP430FR57xx
    ../../../../driverlib/MSP430FR57xx/: eusci_b_i2c.h cs.h comp_d.h sysctl.c eusci_a_spi.c gpio.c adc10_b.h pmm.c timer_b.h framctl.h eusci_a_spi.h eusci_a_uart.h eusci_b_spi.c tlv.h timer_a.h pmm.h eusci_b_i2c.c sysctl.h mpy32.c tlv.c sfr.h comp_d.c timer_b.c mpy32.h wdt_a.h rtc_b.c crc.c dma.c mpu.c eusci_a_uart.c cs.c adc10_b.c mpu.h ref.c gpio.h rtc_b.h dma.h driverlib.h ref.h eusci_b_spi.h framctl.c sfr.c crc.h timer_a.c wdt_a.c
  group driverlib/MSP430FR57xx/inc
    ../../../../driverlib/MSP430FR57xx/inc/: hw_memmap.h version.h
