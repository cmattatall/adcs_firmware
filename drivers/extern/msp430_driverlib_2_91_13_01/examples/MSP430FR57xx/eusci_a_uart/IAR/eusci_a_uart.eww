<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
<project>
    <path>$WS_DIR$\eusci_a_uart_ex1_loopbackAdvanced.ewp</path>
  </project>
  
  <batchBuild/>
</workspace>


