<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
<project>
    <path>$WS_DIR$\ref_ex1_internalReference.ewp</path>
  </project>
  
  <batchBuild/>
</workspace>


