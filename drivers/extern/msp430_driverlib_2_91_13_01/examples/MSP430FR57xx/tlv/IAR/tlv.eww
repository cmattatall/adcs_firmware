<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
<project>
    <path>$WS_DIR$\tlv_ex1_getDeviceType.ewp</path>
  </project>
  
  <batchBuild/>
</workspace>


