<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
<project>
    <path>$WS_DIR$\sd24_ex2_singleConversionGroupChannels.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\sd24_ex1_continuousConversionGroupChannels.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\sd24_ex3_continuousConversionSingleChannel.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\sd24_ex4_singleConversionSingleChannelPolling.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\sd24_ex6_singleConversionSingleConversionTempSensor.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\sd24_ex5_singleConversionSingleChannelInterrupt.ewp</path>
  </project>
  
  <batchBuild/>
</workspace>


