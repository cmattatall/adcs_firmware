# IAR project sd24_ex6_singleConversionSingleConversionTempSensor.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xsfn.h
  General.OGChipSelectMenu: MSP430i2041 MSP430i2041
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: ../../../../driverlib/MSP430i2xx; ../..
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430FR5969.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  ICC430.CCDefines: DEPRECATED
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  group (top)
    ../: sd24_ex6_singleConversionSingleConversionTempSensor.c
  group driverlib/MSP430i2xx
    ../../../../driverlib/MSP430i2xx/: eusci_b_i2c.h cs.h sd24.c eusci_a_spi.c mpy.h gpio.c pmm.c eusci_a_spi.h eusci_a_uart.h eusci_b_spi.c tlv.h timer_a.h pmm.h eusci_b_i2c.c wdt.c tlv.c sfr.h wdt.h flashctl.c sd24.h eusci_a_uart.c cs.c gpio.h mpy.c driverlib.h eusci_b_spi.h sfr.c flashctl.h timer_a.c
  group driverlib/MSP430i2xx/inc
    ../../../../driverlib/MSP430i2xx/inc/: hw_memmap.h version.h
