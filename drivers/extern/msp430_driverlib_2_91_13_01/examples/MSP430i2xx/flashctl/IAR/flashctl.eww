<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
<project>
    <path>$WS_DIR$\flashctl_ex1_infoSegmentWrite.ewp</path>
  </project>
  
  <batchBuild/>
</workspace>


