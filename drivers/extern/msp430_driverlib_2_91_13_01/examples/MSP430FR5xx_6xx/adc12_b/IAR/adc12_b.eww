<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
<project>
    <path>$WS_DIR$\adc12_b_ex2_sharedRef.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\adc12_b_ex1_avccRef.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\adc12_b_ex3_extRef.ewp</path>
  </project>
  
  <batchBuild/>
</workspace>


