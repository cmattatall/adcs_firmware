<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
<project>
    <path>$WS_DIR$\ref_a_ex1_ctlADC12B.ewp</path>
  </project>
  
  <batchBuild/>
</workspace>


