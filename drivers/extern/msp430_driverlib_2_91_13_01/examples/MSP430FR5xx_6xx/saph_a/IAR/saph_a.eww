<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
<project>
    <path>$WS_DIR$\saph_a_ex3_pulseGenerationDMA.ewp</path>
  </project>
  
  <batchBuild/>
</workspace>


