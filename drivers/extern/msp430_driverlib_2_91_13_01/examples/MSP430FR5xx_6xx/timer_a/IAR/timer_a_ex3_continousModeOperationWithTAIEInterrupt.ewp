# IAR project timer_a_ex3_continousModeOperationWithTAIEInterrupt.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xsfn.h
  General.OGChipSelectMenu: MSP430FR5969 MSP430FR5969
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: ../../../../driverlib/MSP430FR5xx_6xx; ../..
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430FR5969.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  ICC430.CCDefines: DEPRECATED
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  group (top)
    ../: timer_a_ex3_continousModeOperationWithTAIEInterrupt.c
  group driverlib/MSP430FR5xx_6xx
    ../../../../driverlib/MSP430FR5xx_6xx/: esi.h eusci_b_i2c.h cs.h adc12_b.c sysctl.c aes256.h eusci_a_spi.c lcd_c.c uups.h framctl_a.h gpio.c framctl_a.c pmm.c timer_b.h framctl.h eusci_a_spi.h eusci_a_uart.h eusci_b_spi.c esi.c tlv.h timer_a.h pmm.h eusci_b_i2c.c sdhs.c adc12_b.h sysctl.h mpy32.c mtif.c saph.c tlv.c sfr.h ref_a.h timer_b.c mpy32.h wdt_a.h saph.h ref_a.c rtc_b.c crc.c saph_a.c dma.c mpu.c eusci_a_uart.c cs.c aes256.c crc32.h mpu.h mtif.h comp_e.c lcd_c.h rtc_c.h gpio.h rtc_b.h comp_e.h ram.h uups.c saph_a.h ram.c dma.h driverlib.h hspll.h crc32.c eusci_b_spi.h framctl.c sdhs.h sfr.c crc.h timer_a.c hspll.c rtc_c.c wdt_a.c
  group driverlib/MSP430FR5xx_6xx/inc
    ../../../../driverlib/MSP430FR5xx_6xx/inc/: hw_memmap.h version.h
