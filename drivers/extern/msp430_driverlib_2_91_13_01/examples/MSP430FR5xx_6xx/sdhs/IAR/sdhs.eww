<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
<project>
    <path>$WS_DIR$\sdhs_ex1_8msps_sampling.ewp</path>
  </project>
  
  <batchBuild/>
</workspace>


