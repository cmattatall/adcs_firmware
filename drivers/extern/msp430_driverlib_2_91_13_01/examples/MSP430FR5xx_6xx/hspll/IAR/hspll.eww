<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
<project>
    <path>$WS_DIR$\hspll_ex1_output_ussxtosc.ewp</path>
  </project>
  
  <batchBuild/>
</workspace>


