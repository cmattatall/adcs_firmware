# IAR project timer_a_ex2_continousModeOperationWithCCR0Interrupt.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xssfn.h
  General.OGChipSelectMenu: MSP430FR4133 MSP430FR4133
  General.GStackSize2: 160
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: DEPRECATED
  ICC430.newCCIncludePaths: ../../../../driverlib/MSP430FR2xx_4xx; ../..
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: lnk0t.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  ICC430.ADefines: NDEBUG
  group (top)
    ../: timer_a_ex2_continousModeOperationWithCCR0Interrupt.c
    ../../: Board.h
  group driverlib/MSP430FR2xx_4xx
    ../../../../driverlib/MSP430FR2xx_4xx/: lcd_e.h eusci_b_i2c.h rtc.c ecomp.h cs.h sysctl.c eusci_a_spi.c lcd_e.c sac.h gpio.c adc.c pmm.c timer_b.h framctl.h eusci_a_spi.h eusci_a_uart.h eusci_b_spi.c tia.h tlv.h timer_a.h pmm.h eusci_b_i2c.c sysctl.h mpy32.c tlv.c sfr.h ecomp.c timer_b.c mpy32.h wdt_a.h icc.c crc.c icc.h tia.c eusci_a_uart.c cs.c sac.c rom_map_driverlib.h gpio.h driverlib.h eusci_b_spi.h rom_driverlib.h adc.h framctl.c sfr.c crc.h timer_a.c rtc.h wdt_a.c
  group driverlib/MSP430FR2xx_4xx/inc
    ../../../../driverlib/MSP430FR2xx_4xx/inc/: hw_memmap.h version.h
  group driverlib/MSP430FR2xx_4xx/rom_headers
    ../../../../driverlib/MSP430FR2xx_4xx/rom_headers/: rom_driverlib_fr235x.h rom_driverlib_fr253x_fr263x.h rom_driverlib_fr2676.h
