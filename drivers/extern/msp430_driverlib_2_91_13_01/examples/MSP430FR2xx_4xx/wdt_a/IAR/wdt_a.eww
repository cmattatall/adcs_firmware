<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
<project>
    <path>$WS_DIR$\wdt_a_ex1_intervalSMCLK.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\wdt_a_ex3_watchdogACLK.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\wdt_a_ex2_intervalACLK.ewp</path>
  </project>
  
  <batchBuild/>
</workspace>


