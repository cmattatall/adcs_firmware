<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
<project>
    <path>$WS_DIR$\tia_ex1_twoExternalInputs.ewp</path>
  </project>
  
  <batchBuild/>
</workspace>


