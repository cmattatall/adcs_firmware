<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
<project>
    <path>$WS_DIR$\icc_ex1_nestedInterrupt.ewp</path>
  </project>
  
  <batchBuild/>
</workspace>


