<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
<project>
    <path>$WS_DIR$\adc_ex2_intRef.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\adc_ex1_avccRef.ewp</path>
  </project>
  
  <batchBuild/>
</workspace>


